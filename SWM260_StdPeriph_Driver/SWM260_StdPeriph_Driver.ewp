# IAR project SWM260_StdPeriph_Driver.ewp, settings and files
configuration SWM260 (ARM, debug)
  General.OGChipSelectEditMenu: SWM260xB Synwit SWM260xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: .\CSL\CMSIS\CoreSupport; .\CSL\CMSIS\DeviceSupport; .\CSL\SWM260_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR
  OBJCOPY.OOCOutputFile: SWM260_StdPeriph_Driver.srec
  ILINK.IlinkOutputFile: SWM260_StdPeriph_Driver.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM260_StdPeriph_Driver/: SWM260_port.c SWM260_gpio.c SWM260_exti.c SWM260_timr.c SWM260_uart.c SWM260_adc.c SWM260_dma.c SWM260_i2c.c SWM260_pwm.c SWM260_spi.c SWM260_flash.c SWM260_rtc.c SWM260_wdt.c SWM260_sleep.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM260.c
    ./CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM260.s
