# IAR project Segger_RTT.ewp, settings and files
configuration SWM260 (ARM, debug)
  General.OGChipSelectEditMenu: SWM260xB Synwit SWM260xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\SWM260_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM260_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM260_StdPeriph_Driver\CSL\SWM260_StdPeriph_Driver; .\APP\RTT
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR
  OBJCOPY.OOCOutputFile: Segger_RTT.srec
  ILINK.IlinkOutputFile: Segger_RTT.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./app/: main.c
  group RTT
    ./APP/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group CSL\StdPD
    ../../SWM260_StdPeriph_Driver/CSL/SWM260_StdPeriph_Driver/: SWM260_adc.c SWM260_exti.c SWM260_gpio.c SWM260_i2c.c SWM260_pwm.c SWM260_timr.c SWM260_uart.c SWM260_wdt.c SWM260_dma.c SWM260_flash.c SWM260_port.c SWM260_spi.c SWM260_rtc.c
  group CSL\CMSIS
    ../../SWM260_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM260.c
    ../../SWM260_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM260.s
