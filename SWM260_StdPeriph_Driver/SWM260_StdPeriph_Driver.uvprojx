# Keil uVision project SWM260_StdPeriph_Driver.uvprojx, settings and files
target SWM260 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM260xB Synwit
  pack: Synwit.SWM32_DFP.1.19.6
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SWM260_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM260_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM260_StdPeriph_Driver/: SWM260_port.c SWM260_gpio.c SWM260_exti.c SWM260_timr.c SWM260_uart.c SWM260_adc.c SWM260_dma.c SWM260_i2c.c SWM260_pwm.c SWM260_spi.c SWM260_flash.c SWM260_rtc.c SWM260_wdt.c SWM260_sleep.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM260.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM260.s
